# IAR project IAR.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F429VG ST STM32F429VG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: STM32F429xx
  ICCARM.CCIncludePath2: ..\; ..\CMSIS\Include; ..\FreeRTOS\; ..\FreeRTOS\include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  OBJCOPY.OOCOutputFile: IAR.hex
  ILINK.IlinkOutputFile: IAR.out
  ILINK.IlinkIcfFile: stm32f429xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ../: main.cpp
  group _EWARM
    ./: startup_stm32f429xx.s stm32f429xx_flash.icf
  group CMSIS/Device
    ../CMSIS/Device/: stm32f429xx.h stm32f4xx.h system_stm32f4xx.c system_stm32f4xx.h
  group CMSIS/Include
    ../CMSIS/Include/: core_cm4.h core_cmFunc.h core_cmInstr.h core_cmSimd.h
  group FreeRTOS
    ../FreeRTOS/: FreeRTOSConfig.h port.c portasm.s portmacro.h
  group FreeRTOS/include
    ../FreeRTOS/include/: deprecated_definitions.h FreeRTOS.h list.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h task.h timers.h
  group FreeRTOS/src
    ../FreeRTOS/src/: heap_2.c list.c queue.c tasks.c timers.c
  group user
    ../user/: CAN.cpp RCC.cpp
