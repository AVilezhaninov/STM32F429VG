# IAR project IAR.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F429VG ST STM32F429VG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: STM32F429xx
  ICCARM.CCIncludePath2: ..\source\CMSIS\Include; ..\source\CMSIS\Device\ST\STM32F4xx\Include; ..\source\user\inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: IAR.hex
  ILINK.IlinkOutputFile: IAR.out
  ILINK.IlinkIcfFile: ..\source\CMSIS\Device\ST\STM32F4xx\Source\iar\linker\stm32f429xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group CMSIS/Device/ST/STM32F4xx/Include
    ../source/CMSIS/Device/ST/STM32F4xx/Include/: stm32f429xx.h stm32f4xx.h system_stm32f4xx.h
  group CMSIS/Device/ST/STM32F4xx/Source
    ../source/CMSIS/Device/ST/STM32F4xx/Source/: system_stm32f4xx.c
  group CMSIS/Device/ST/STM32F4xx/Source/iar
    ../source/CMSIS/Device/ST/STM32F4xx/Source/iar/: startup_stm32f429xx.s
  group CMSIS/Device/ST/STM32F4xx/Source/iar/linker
    ../source/CMSIS/Device/ST/STM32F4xx/Source/iar/linker/: stm32f429xx_flash.icf
  group CMSIS/Include
    ../source/CMSIS/Include/: arm_common_tables.h arm_const_structs.h arm_math.h cmsis_gcc.h core_cm4.h core_cmFunc.h core_cmInstr.h core_cmSimd.h
  group user
    ../source/: main.c
  group user/inc
    ../source/user/inc/: RCC.h
  group user/src
    ../source/user/src/: RCC.c
